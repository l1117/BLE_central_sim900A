# Keil uVision project ble_app_hrs_c_s120_pca10028.uvprojx, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD S120 SOFTDEVICE_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../../: main.c battery.c spi_master.c simple_uart.c
    ../../../../../components/ble/ble_radio_notification/: ble_radio_notification.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    RTE/nRF_BLE/nRF51822_xxAA/: ble_db_discovery.c ble_db_discovery.h device_manager_cnfg.h
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/2.0.0/common/: ble_srv_common.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/2.0.0/device_manager/: device_manager_central.c
  group ::nRF_Drivers
    RTE/nRF_Drivers/nRF51822_xxAA/: app_uart.h pstorage.c pstorage.h pstorage_platform.h app_uart.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/2.0.0/hal/: nrf_delay.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51822_xxAA/: app_error.c app_error.h app_fifo.c app_fifo.h app_gpiote.h app_timer.c app_timer.h app_trace.c app_trace.h nrf_assert.c nrf_assert.h retarget.c app_gpiote.c
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51822_xxAA/: s120_nrf51822_2.0.0_licence_agreement.txt softdevice_handler.c
software components: CMSIS:CORE 3.20.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_db_discovery 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Modules:device_manager 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:retarget 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s120 2.0.0
